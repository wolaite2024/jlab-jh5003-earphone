# Keil uVision project ble_audio_lib.uvprojx, settings and files
target rtl87x3d (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: leaudio +hex (library)
  AfterMake: cmd.exe /c ble_audio_lib_after_build.bat 3d && echo %TIME%
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CONFIG_REALTEK_BLE_USE_UAL_API=0, CONFIG_REALTEK_LE_AUDIO_USE_BLE_EXT_ADV=1
  c misc: --gnu --preinclude ble_audio_flags.h --preinclude upperstack_config.h --bss_threshold=0
  c include: ..\..\..\inc\bluetooth\gap;..\..\..\inc\bluetooth\profile;..\..\..\src\app\ble_audio_lib\inc_int;..\..\..\src\app\ble_audio_lib\util;..\..\..\src\app\ble_audio_lib\adv_scan;..\..\..\src\app\ble_audio_lib\bap;..\..\..\src\app\ble_audio_lib\csip;..\..\..\src\app\ble_audio_lib\vcp;..\..\..\src\app\ble_audio_lib\mcp;..\..\..\src\app\ble_audio_lib\otp;..\..\..\src\app\ble_audio_lib\micp;..\..\..\src\app\ble_audio_lib\ccp;..\..\..\src\app\ble_audio_lib\tmap;..\..\..\src\app\ble_audio_lib;..\..\..\src\app\ble_audio_lib\cap;..\..\..\src\app\ble_audio_lib\bt_mgr;..\..\..\inc\app;..\..\..\src\ble\gatt_client;..\..\..\src\app\bt_ual\inc_int;..\..\..\src\app\bt_ual;..\..\..\inc\rtl87x3d\hal;..\..\..\inc\os;..\..\..\inc\rtl87x3d\platform;..\..\..\inc\platform;..\..\..\inc\framework\bt;..\..\..\inc\ble_mgr;..\..\..\inc\rtl87x3d\bluetooth\gap;..\..\..\inc\bluetooth\leaudio;..\..\..\inc\framework\sysm;..\..\..\inc\hal\platform;..\..\..\inc\hal\io
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\audio_test.sct
  link misc: --diag_suppress=L6314 --datacompressor off
  group bap
    ../../../src/app/ble_audio_lib/bap/: ascs.c ascs_client.c ascs_client_cp.c ascs_mgr.c ase_handle_cp.c ase_sm.c bap.c base_data_parse.c bass_client.c bass_mgr.c codec_qos.c pac_mgr.c pacs.c pacs_client.c pacs_mgr.c bap_unicast_client.c bass_brs_mgr.c base_data_generate.c
  group csip
    ../../../src/app/ble_audio_lib/csip/: csis.c csis_client.c csis_mgr.c csis_rsi.c csis_sir.c set_coordinator_client.c set_member.c
  group vcp
    ../../../src/app/ble_audio_lib/vcp/: aics.c aics_client.c aics_mgr.c vcs.c vcs_client.c vcs_mgr.c vocs.c vocs_client.c vocs_mgr.c
  group util
    ../../../src/app/ble_audio_lib/util/: ble_audio_dm.c ble_audio_mgr.c ble_link_util.c codec.c ltv_util.c metadata.c ble_audio_group.c audio_stream_session.c ble_audio_ual.c bt_bond_gap.c ble_audio_mem.c calculate_util.c
  group bt_mgr
    ../../../src/app/ble_audio_lib/bt_mgr/: ble_audio_sync.c broadcast_source_sm.c
  group mcp
    ../../../src/app/ble_audio_lib/mcp/: mcp_client.c mcp_mgr_obj_str.c mcp_mgr.c
  group cap
    ../../../src/app/ble_audio_lib/cap/: cas.c cap.c
  group micp
    ../../../src/app/ble_audio_lib/micp/: mics.c mics_client.c mics_mgr.c
  group ccp
    ../../../src/app/ble_audio_lib/ccp/: ccp_client.c ccp_mgr.c tbs_server.c tbs_client.c
  group tmap
    ../../../src/app/ble_audio_lib/tmap/: tmas_mgr.c tmas_client.c
  group hap
    ../../../src/app/ble_audio_lib/hap/: has_client.c has_mgr.c
  group gmap
    ../../../src/app/ble_audio_lib/gmap/: gmas_mgr.c gmas_client.c
