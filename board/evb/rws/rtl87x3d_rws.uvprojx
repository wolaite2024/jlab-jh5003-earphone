# Keil uVision project rtl87x3d_rws.uvprojx, settings and files
target stereo_16M_dual_bank0_gaming (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: stereo
  BeforeMake: cmd.exe /c rtl87x3d_before_build_script.bat flash_16M "0" rtl87x3d default
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank0  flash_16M_stereo rtl87x3d
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CHARGE_UTIL=0 CONFIG_REALTEK_APP_BOND_MGR_SUPPORT = 1 CONFIG_SOC_SERIES_RTL8773D=1 F_APP_STEREO=1 CUSTOMIZED_TUYA_BLE_CONFIG_FILE="rtk_tuya_ble_config.h" TARGET_LEGACY_AUDIO_GAMING=1 TARGET_DISABLE_LEA_SUPPORT=1
  c misc: --gnu --bss_threshold=0 --diag_suppress=177 --preinclude app_flags.h --preinclude app_lea_flags.h --preinclude ble_audio_flags.h
  c include: .\inc\rtl87x3d;..\..\..\inc\app;..\..\..\inc\bluetooth\gap;..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\inc\framework\sysm;..\..\..\inc\framework\audio;..\..\..\inc\framework\bt;..\..\..\inc\framework\remote;..\..\..\inc\framework\console;..\..\..\inc\bluetooth\profile;..\..\..\inc\bluetooth\profile\server;..\..\..\inc\bluetooth\profile\client;..\..\..\inc\rtl87x3d\hal;..\..\..\inc\os;..\..\..\inc\rtl87x3d\io;..\..\..\inc\rtl87x3d\platform;..\..\..\inc\rtl87x3d\platform\cmsis;..\..\..\inc\stack;..\..\..\inc\service\gfps;..\rws;..\..\..\src\ble\adv_mgr;..\..\..\src\ble\ble_conn_update;..\..\..\src\sample\rws\gfps;..\..\..\src\mcu\module\led;..\..\..\src\sample\rws\local_playback;..\..\..\src\sample\rws\local_playback\sd_emmc;..\..\..\src\sample\rws;..\..\..\src\sample\rws\bqb;..\..\..\src\sample\rws\console;..\..\..\src\sample\rws\cli;..\..\..\src\sample\rws\bud;..\..\..\src\sample\rws\mp;..\..\..\src\sample\rws\app;..\..\..\src\mcu\legacy\spp_ota;..\..\..\src\sample\rws\engage;..\..\..\src\app\engage;..\..\..\src\mcu\module\stream;..\..\..\src\sample\rws\xiaoai;..\..\..\inc\service;..\..\..\src\service\bisto\bisto_info;..\..\..\src\sample\rws\bisto;..\..\..\src\service\bisto;..\..\..\src\service\bisto\bisto_utilities;..\..\..\src\service\bisto\bisto_bt;..\..\..\src\service\bisto\gsound;..\..\..\src\sample\rws\bisto;..\..\..\src\service\bisto\bisto_btns;..\..\..\src\service\bisto\bisto_actions;..\..\..\src\service\ama\protobuf;..\..\..\src\sample\rws\ama;..\..\..\inc\service\bisto;..\..\..\inc\service\xiaoai;..\..\..\inc\service\ama;..\..\..\src\service\bisto\bisto_ble;..\..\..\src\ble\gatt_client;..\..\..\src\mcu\module\vector;..\..\..\src\service\gfps;..\..\..\src\sample\rws\eq;..\..\..\src\sample\rws\dongle;..\..\..\src\sample\rws\teams;..\..\..\inc\service\teams;..\..\..\inc\service\teams\asp_device;..\..\..\inc\service\teams\hid;..\..\..\src\sample\rws\teams\asp_device;..\..\..\src\sample\rws\teams\hid;..\..\..\src\sample\rws\teams;..\..\..\src\debug;..\..\..\src\sample\rws\lea;..\..\..\inc\bluetooth\leaudio;..\..\..\bin\rtl87x3d\upperstack_stamp;..\..\..\inc\hal\power;..\..\..\bin\rtl87x3d\flash_map_config;..\..\..\src\sample\rws\tuya\rtk_tuya_ble_app;..\..\..\src\sample\rws\tuya\tuya_enc\mbedtls;..\..\..\src\sample\rws\tuya\rtk_tuya_ble_port;..\..\..\src\sample\rws\tuya\tuya_ble_sdk;..\..\..\src\sample\rws\tuya\tuya_enc;..\..\..\inc\ble_mgr;..\..\..\src\sample\rws\usb;..\..\..\inc\service\teams\ble;..\..\..\src\sample\rws\teams\cfu;..\..\..\src\sample\rws\teams\cfu\Signature;..\..\..\inc\rtl87x3d\usb\class;..\..\..\inc\rtl87x3d\usb\composite;..\..\..\inc\hal\power;..\..\..\src\sample\rws\ipc;..\..\..\src\sample\rws\xiaowei;..\..\..\inc\service\xiaowei;..\..\..\inc\rtl87x3d\hal\io;..\..\..\src\sample\rws\bond;..\..\..\inc\ble_mgr\bond;..\..\..\src\sample\rws\usb\audio;..\..\..\src\sample\rws\usb\hid;..\..\..\src\mcu\module\console\transport;..\..\..\inc\usb\class;..\..\..\inc\usb\composite;..\..\..\src\sample\rws\ha;..\..\..\src\sample\rws\speaker;..\..\..\inc\hal\platform;..\..\..\inc\hal\io;..\..\..\src\sample\rws\test;..\..\..\src\ble\bt_gatt_svc;..\..\..\inc\platform;..\..\..\src\sample\common;..\..\..\src\mcu\module\buck;..\..\..\src\mcu\module\rtk_charger;..\..\..\src\mcu\module\eq;..\..\..\bin\rtl87x3d\flash_map_config;..\..\..\inc\rtl87x3d\hal\stack;..\..\..\inc\usb;..\..\..\src\sample\common\app_ble_service;..\..\..\src\mcu\module\malleus;..\..\..\src\sample\rws\chatgpt;..\..\..\src\sample\rws\multitopology;..\..\..\src\mcu\module\data_transfer;..\..\..\src\sample\common\usb
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\cfg\rtl87x3d\rtl87x3d_stereo_bank0.sct
  link misc: --diag_suppress=L6314 --datacompressor off
  group include
    ./: config.h
    ../../../inc/rtl87x3d/platform/: rom_uuid.h
  group lib
    ../../../bin/rtl87x3d/: gfps.lib teams.lib xiaoai.lib xiaowei.lib xiaoai_auth_lib.lib engage.lib gap_utils.lib ROM.lib hal_utils.lib tuya_ble_sdk_v2.0.0_lib_arm_m4f_keil.lib ble_mgr.lib usb.lib ama.lib gaming_bt.lib usb_hal.lib malleus_secp.lib
    ../../../bin/rtl87x3d/framework/: audio.lib console.lib sysm.lib remote.lib btm.lib
    ../../../bin/rtl87x3d/leaudio/: leaudio.lib
    ../../../src/sample/rws/teams/cfu/Signature/: CryptoLibECC.lib
  group cmsis
    ../../../src/mcu/rtl87x3/: system_rtl87x3.c
    ../../../src/mcu/rtl87x3/arm/: startup_rtl87x3d.s
  group io_driver
    ../../../src/mcu/io/rtl87x3d/: rtl876x_pinmux.c rtl876x_gdma.c rtl876x_rcc.c rtl876x_sleep_led.c rtl876x_tim.c rtl876x_uart.c rtl876x_i2c.c rtl876x_gpio.c rtl876x_adc.c rtl876x_qdec.c
  group io_hal
    ../../../src/mcu/io_hal/common/: hw_tim.c hal_gpio.c hal_i2c.c hal_dma_internal.c hal_pinmux.c pwm.c
    ../../../src/mcu/io_hal/rtl87x3d/: hal_gpio_int.c
  group io
    ../../../src/sample/rws/: app_sensor_iqs773_873.c app_vendor_iqs773_873.c
    ../../../src/mcu/module/buck/: app_buck_apw7564.c app_buck_tps62860.c
  group module
    ../../../src/mcu/module/led/: led_module.c
    ../../../src/mcu/module/stream/: ble_stream.c iap_stream.c spp_stream.c common_stream.c
    ../../../src/mcu/module/vector/: vector.c
    ../../../src/sample/rws/: image_header.c
    ../../../src/mcu/module/charger_info/: charger_utils.c
    ../../../src/mcu/module/eq/: eq_utils.c eq_ext_ftl.c
    ../../../src/mcu/module/data_transfer/: data_transfer.c
  group console
    ../../../src/mcu/module/console/transport/: console_uart.c
  group cli
    ../../../src/sample/rws/cli/: cli_cfg_cmd.c cli_cfg_main.c cli_power_cmd.c cli_lpm_cmd.c
  group bqb
    ../../../src/sample/rws/bqb/: bqb_main.c bqb_cmd.c
  group ble
    ../../../src/ble/profile/client/: ancs_client.c ams_client.c
    ../../../src/ble/profile/server/: bas.c dis.c
    ../../../src/ble/gatt_client/: gattc_tbl_storage.c bt_ext_ftl.c
    ../../../src/ble/bt_gatt_svc/: asp_svc.c transmit_svc_dongle.c ias_gatt_svc.c
    ../../../src/sample/common/app_ble_service/: ota_service.c transmit_service.c rtk_vendor_dis_gatt_svc.c
  group xiaoai
    ../../../src/sample/rws/xiaoai/: app_xm_xiaoai.c app_xiaoai_device.c app_xiaoai_record.c app_xm_xiaoai_ble_adv.c app_xiaoai_transport.c app_xm_xiaoai_rfc.c app_xiaoai_ota.c app_xiaoai_ota_flash.c app_xiaoai_rcsp.c xm_auth.c
  group xiaowei
    ../../../src/sample/rws/xiaowei/: app_xiaowei.c app_xiaowei_ble_adv.c app_xiaowei_device.c app_xiaowei_record.c app_xiaowei_rfc.c app_xiaowei_transport.c
  group app
    ../../../src/sample/rws/: app_main.c app_cfg.c app_io_msg.c app_led.c app_key_gpio.c app_key_process.c app_charger.c app_transfer.c app_report.c app_gap.c app_ble_gap.c app_ble_device.c app_ble_client.c app_ble_service.c app_ble_common_adv.c app_sdp.c app_hfp.c app_avrcp.c app_a2dp.c app_pbap.c app_iap.c app_roleswap.c app_relay.c app_device.c app_mmi.c app_dlps.c app_link_util.c app_linkback.c app_multilink.c app_bt_policy.c app_audio_policy.c app_rdtp.c app_test.c app_anc.c app_eq.c app_nfc.c app_sensor.c app_ota.c app_bt_policy_api.c app_in_out_box.c app_vad.c app_iap_rtk.c app_bond.c app_third_party_srv.c app_bt_sniffing.c app_audio_passthrough.c app_adp.c app_io_output.c app_console_msg.c app_cap_touch.c app_spp.c app_cmd.c app_listening_mode.c app_sensor_px318j.c app_auto_power_off.c app_line_in.c app_airplane.c app_adc.c app_ble_swift_pair.c app_audio_route.c app_hid.c app_qol.c app_hearable.c app_slide_switch.c app_ble_bond.c app_sensor_jsa.c app_audio_passthrough_brightness.c app_bud_loc.c app_ble_rand_addr_mgr.c app_roleswap_control.c app_amp.c app_single_multilink_customer.c app_adp_cmd.c app_adp_cmd_parse.c app_loc_mgr.c app_ipc.c app_tts.c app_ble_sc_key_derive.c app_console.c app_sensor_i2c.c app_data_capture.c app_qdec.c app_ble_whitelist.c app_vendor.c app_sass_policy.c app_eq_fitting.c app_stream.c app_audio_hearing.c app_ble_gatt_caching.c app_lhdc.c app_att.c app_rtk_fast_pair_adv.c app_ble_eatt.c app_bt_point.c app_ext_mic_switch.c app_wlt_ui.c
    ../../../src/sample/common/: app_util.c app_data_transfer.c app_gpio_on_off.c app_buzeer.c app_dsp_cfg.c app_sniff_mode.c app_one_wire_uart.c app_ota_tooling.c app_common_cfu.c app_cfu_transfer.c app_sidetone.c app_nrec.c
    ../../../src/mcu/module/rtk_charger/: rtk_charger.c
    ../../../src/sample/rws/usb/audio/: app_usb_audio.c
    ../../../src/sample/rws/usb/hid/: app_usb_mmi.c app_usb_hid_cmd.c
    ../../../src/sample/rws/dongle/: app_dongle_dual_mode.c
    ../../../src/sample/rws/usb/: app_usb.c
    ../../../src/sample/rws/ha/: ha_ext_ftl.c
    ../../../src/sample/rws/speaker/: app_multilink_customer.c
  group mp
    ../../../src/sample/rws/mp/: cli_mp_main.c mp_test.c mp_test_vendor.c single_tone.c
  group gfps
    ../../../src/sample/rws/gfps/: app_gfps.c app_gfps_account_key.c app_gfps_device.c app_gfps_personalized_name.c app_gfps_rfc.c app_ecc.c app_gfps_battery.c app_gfps_sync.c app_gfps_link.c app_gfps_msg.c app_gfps_psm.c app_gfps_finder.c app_gfps_finder_adv.c app_gfps_finder_test_internal.c app_gfps_timer.c app_dult.c app_dult_device.c app_dult_svc.c
  group ama
    ../../../src/sample/rws/ama/: app_ama.c app_ama_accessory.c app_ama_ble.c app_ama_device.c app_ama_record.c app_ama_roleswap.c app_ama_spp.c app_ama_timer.c app_ama_transport.c app_ama_tone.c
  group teams
    ../../../src/sample/rws/teams/asp_device/: app_asp_device.c app_asp_device_rfc.c
    ../../../src/sample/rws/teams/hid/: app_teams_hid.c
    ../../../src/sample/rws/teams/: app_teams_rws.c app_teams_audio_policy.c app_teams_bt_policy.c app_teams_cmd.c app_teams_customized_cmd.c app_teams_extend_led.c app_teams_util.c app_teams_ble_policy.c app_teams_ext_ftl.c
    ../../../src/sample/rws/teams/cfu/Signature/: CryptoInterface.c ProdCA.S TestCA.S
  group tuya
    ../../../src/sample/rws/tuya/rtk_tuya_ble_app/: rtk_tuya_app_product_test.c rtk_tuya_app_uart_common_handler.c rtk_tuya_app_ext_ftl.c rtk_tuya_ble_adv.c rtk_tuya_ble_app_demo.c rtk_tuya_ble_device.c rtk_tuya_ble_service.c rtk_tuya_app_relay.c rtk_tuya_app_dp.c rtk_tuya_ble_ota.c rtk_tuya_ble_ota_flash.c
    ../../../src/sample/rws/tuya/tuya_enc/mbedtls/: rtk_tuya_aes_test.c hmac.c md5.c sha1.c sha256.c
    ../../../src/sample/rws/tuya/rtk_tuya_ble_port/: rtk_tuya_ble_port_rtl8773c.c
    ../../../src/sample/rws/tuya/tuya_ble_sdk/: tuya_ble_api.c tuya_ble_app_production_test.c tuya_ble_app_uart_common_handler.c tuya_ble_bulk_data.c tuya_ble_data_handler.c tuya_ble_event.c tuya_ble_event_handler.c tuya_ble_event_handler_weak.c tuya_ble_feature_weather.c tuya_ble_gatt_send_queue.c tuya_ble_heap.c tuya_ble_main.c tuya_ble_mem.c tuya_ble_mutli_tsf_protocol.c tuya_ble_port.c tuya_ble_port_peripheral.c tuya_ble_queue.c tuya_ble_storage.c tuya_ble_unix_time.c tuya_ble_utils.c
  group lea
    ../../../src/sample/rws/lea/: app_lea_adv.c app_lea_ascs.c app_lea_ccp.c app_lea_csis.c app_lea_mcp.c app_lea_pacs.c app_lea_scan.c app_lea_vcs.c app_lea_mgr.c app_lea_profile.c cli_le_audio.c app_lea_realcast.c app_lea_unicast_audio.c app_lea_vol_policy.c app_lea_broadcast_audio.c app_lea_mics.c app_lea_has.c app_lea_has_preset_record.c
  group bond
    ../../../src/sample/rws/bond/: ble_audio_bond.c ble_bond_sync.c
  group dongle
    ../../../src/sample/rws/dongle/: app_dongle_record.c app_dongle_spp.c app_dongle_common.c app_dongle_source_ctrl.c app_dongle_data_ctrl.c app_dongle_audio.c
    ../../../src/sample/common/: app_gaming_sync.c
  group usb
    ../../../src/sample/rws/usb/audio/: usb_audio1.c usb_audio2.c usb_audio_stream.c
    ../../../src/sample/rws/usb/hid/: usb_hid.c
    ../../../src/sample/rws/usb/: usb_dev.c
    ../../../src/sample/common/usb/: usb_host_detect.c
  group ipc
    ../../../src/sample/rws/ipc/: ipc.c
  group mtc
    ../../../src/sample/rws/multitopology/: multitopology_ctrl.c
  group test
    ../../../src/sample/rws/test/: app_power_test.c
  group chatgpt
    ../../../src/sample/rws/chatgpt/: app_chatgpt.c app_chatgpt_ble.c app_chatgpt_process.c app_chatgpt_transport.c
  group malleus
    ../../../src/mcu/module/malleus/: malleus.c
    ../../../src/sample/rws/: app_malleus.c
target stereo_16M_dual_bank1_gaming (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: stereo
  BeforeMake: cmd.exe /c rtl87x3d_before_build_script.bat flash_16M "1" rtl87x3d default
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank1  flash_16M_stereo rtl87x3d
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: as above
  c include: as above
  asm misc: --cpreproc
  asm include: ..\..\..\inc\platform;..\..\..\inc\rtl87x3d\platform
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\cfg\rtl87x3d\rtl87x3d_stereo_bank1.sct
  link misc: --diag_suppress=L6314 --datacompressor off
target stereo_8M_dual_bank0_gaming (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: as above
  output: stereo
  BeforeMake: cmd.exe /c rtl87x3d_before_build_script.bat flash_8M "0" rtl87x3d default
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank0  flash_8M_stereo rtl87x3d
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CHARGE_UTIL=0 CONFIG_REALTEK_APP_BOND_MGR_SUPPORT = 1 TARGET_RTL8773DFL=1 F_APP_STEREO=1 CUSTOMIZED_TUYA_BLE_CONFIG_FILE="rtk_tuya_ble_config.h" TARGET_LEGACY_AUDIO_GAMING=1 TARGET_DISABLE_LEA_SUPPORT=1
  c misc: as above
  c include: .\inc\rtl87x3d;..\..\..\inc\app;..\..\..\inc\bluetooth\gap;..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\inc\framework\sysm;..\..\..\inc\framework\audio;..\..\..\inc\framework\bt;..\..\..\inc\framework\remote;..\..\..\inc\framework\console;..\..\..\inc\bluetooth\profile;..\..\..\inc\bluetooth\profile\server;..\..\..\inc\bluetooth\profile\client;..\..\..\inc\rtl87x3d\hal;..\..\..\inc\os;..\..\..\inc\rtl87x3d\io;..\..\..\inc\rtl87x3d\platform;..\..\..\inc\rtl87x3d\platform\cmsis;..\..\..\inc\stack;..\..\..\inc\service\gfps;..\rws;..\..\..\src\ble\adv_mgr;..\..\..\src\ble\ble_conn_update;..\..\..\src\sample\rws\gfps;..\..\..\src\mcu\module\led;..\..\..\src\sample\rws\local_playback;..\..\..\src\sample\rws\local_playback\sd_emmc;..\..\..\src\sample\rws;..\..\..\src\sample\rws\bqb;..\..\..\src\sample\rws\console;..\..\..\src\sample\rws\cli;..\..\..\src\sample\rws\bud;..\..\..\src\sample\rws\mp;..\..\..\src\sample\rws\app;..\..\..\src\mcu\legacy\spp_ota;..\..\..\src\sample\rws\engage;..\..\..\src\app\engage;..\..\..\src\mcu\module\stream;..\..\..\src\sample\rws\xiaoai;..\..\..\inc\service;..\..\..\src\service\bisto\bisto_info;..\..\..\src\sample\rws\bisto;..\..\..\src\service\bisto;..\..\..\src\service\bisto\bisto_utilities;..\..\..\src\service\bisto\bisto_bt;..\..\..\src\service\bisto\gsound;..\..\..\src\sample\rws\bisto;..\..\..\src\service\bisto\bisto_btns;..\..\..\src\service\bisto\bisto_actions;..\..\..\src\service\ama\protobuf;..\..\..\src\sample\rws\ama;..\..\..\inc\service\bisto;..\..\..\inc\service\xiaoai;..\..\..\inc\service\ama;..\..\..\src\service\bisto\bisto_ble;..\..\..\src\ble\gatt_client;..\..\..\src\mcu\module\vector;..\..\..\src\service\gfps;..\..\..\src\sample\rws\eq;..\..\..\src\sample\rws\dongle;..\..\..\src\sample\rws\teams;..\..\..\inc\service\teams;..\..\..\inc\service\teams\asp_device;..\..\..\inc\service\teams\hid;..\..\..\src\sample\rws\teams\asp_device;..\..\..\src\sample\rws\teams\hid;..\..\..\src\sample\rws\teams;..\..\..\src\debug;..\..\..\src\sample\rws\lea;..\..\..\inc\bluetooth\leaudio;..\..\..\bin\rtl87x3d\upperstack_stamp;..\..\..\inc\hal\power;..\..\..\bin\rtl87x3d\flash_map_config;..\..\..\src\sample\rws\tuya\rtk_tuya_ble_app;..\..\..\src\sample\rws\tuya\tuya_enc\mbedtls;..\..\..\src\sample\rws\tuya\rtk_tuya_ble_port;..\..\..\src\sample\rws\tuya\tuya_ble_sdk;..\..\..\src\sample\rws\tuya\tuya_enc;..\..\..\inc\ble_mgr;..\..\..\src\sample\rws\usb;..\..\..\inc\service\teams\ble;..\..\..\src\sample\rws\teams\cfu;..\..\..\src\sample\rws\teams\cfu\Signature;..\..\..\inc\rtl87x3d\usb\class;..\..\..\inc\rtl87x3d\usb\composite;..\..\..\inc\hal\power;..\..\..\src\sample\rws\ipc;..\..\..\src\sample\rws\xiaowei;..\..\..\inc\service\xiaowei;..\..\..\inc\rtl87x3d\hal\io;..\..\..\src\sample\rws\bond;..\..\..\inc\ble_mgr\bond;..\..\..\src\sample\rws\usb\audio;..\..\..\src\sample\rws\usb\hid;..\..\..\src\mcu\module\console\transport;..\..\..\inc\usb\class;..\..\..\inc\usb\composite;..\..\..\src\sample\rws\ha;..\..\..\src\sample\rws\speaker;..\..\..\inc\hal\platform;..\..\..\inc\hal\io;..\..\..\src\sample\rws\test;..\..\..\inc\platform;..\..\..\src\sample\common;..\..\..\src\mcu\module\buck;..\..\..\src\mcu\module\rtk_charger;..\..\..\src\mcu\module\eq;..\..\..\bin\rtl87x3d\flash_map_config;..\..\..\inc\rtl87x3d\hal\stack;..\..\..\src\ble\bt_gatt_svc;..\..\..\inc\usb;..\..\..\src\sample\common\app_ble_service;..\..\..\src\mcu\module\malleus;..\..\..\src\sample\rws\chatgpt;..\..\..\src\sample\rws\multitopology;..\..\..\src\mcu\module\data_transfer;..\..\..\src\sample\common\usb
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\cfg\rtl87x3d\rtl87x3d_stereo_bank0.sct
  link misc: --diag_suppress=L6314 --datacompressor off
target stereo_8M_dual_bank1_gaming (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: as above
  output: stereo
  BeforeMake: cmd.exe /c rtl87x3d_before_build_script.bat flash_8M "1" rtl87x3d default
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank1  flash_8M_stereo rtl87x3d
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: as above
  c include: as above
  asm misc: --cpreproc
  asm include: ..\..\..\inc\platform;..\..\..\inc\rtl87x3d\platform
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\cfg\rtl87x3d\rtl87x3d_stereo_bank1.sct
  link misc: --diag_suppress=L6314 --datacompressor off
