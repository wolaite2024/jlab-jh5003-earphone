# Keil uVision project audio.uvprojx, settings and files
target rtl87x3d (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: audio +hex (library)
  AfterMake: cmd.exe /c audio_after_build.bat 3d && echo %TIME%
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CONFIG_REALTEK_AM_AUDIO_LINE_SUPPORT=1 CONFIG_REALTEK_AM_AUDIO_PIPE_SUPPORT=1 CONFIG_REALTEK_AM_ANC_SUPPORT=1 AM_ADSP_SUPPORT=1 CONFIG_REALTEK_AM_AUDIO_PLUGIN_SUPPORT=1 CONFIG_SOC_SERIES_RTL8773D CONFIG_REALTEK_AM_VAD_SUPPORT=1 CONFIG_REALTEK_AM_KWS_SUPPORT=1
  c misc: --gnu --bss_threshold=0
  c include: ..\..\..\..\inc\os;..\..\..\..\inc\platform;..\..\..\..\inc\hal\platform;..\..\..\..\inc\rtl87x3d\platform;..\..\..\..\inc\hal\power;..\..\..\..\inc\hal\io;..\..\..\..\inc\hal\audio;..\..\..\..\inc\app;..\..\..\..\src\framework\btm;..\..\..\..\inc\framework\bt;..\..\..\..\inc\framework\sysm;..\..\..\..\inc\framework\audio;..\..\..\..\inc\framework\remote;..\..\..\..\src\framework\audio\path\analog;..\..\..\..\src\framework\audio\path\plugin;..\..\..\..\src\framework\audio\path\loader;..\..\..\..\src\framework\audio\path\digital;..\..\..\..\src\framework\audio\path\gateway;..\..\..\..\src\framework\audio\core;..\..\..\..\src\framework\audio\effect;..\..\..\..\src\framework\audio\notification;..\..\..\..\src\framework\audio\path;..\..\..\..\src\framework\audio\probe;..\..\..\..\src\framework\audio\route;..\..\..\..\src\framework\audio\signal;..\..\..\..\src\framework\audio\stream;..\..\..\..\src\framework\audio\volume
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6314 --datacompressor off
  group core
    ../../../../src/framework/audio/core/: audio_codec.c audio_interval_eval.c audio_latency.c audio_mgr.c audio_remote.c jitter_buffer.c media_buffer.c media_pool.c
    ../../../../src/framework/audio/signal/: kws.c
  group notification
    ../../../../src/framework/audio/notification/: notification.c notification_buffer.c ringtone.c tts.c voice_prompt.c
  group path
    ../../../../src/framework/audio/path/: audio_path.c
    ../../../../src/framework/audio/path/analog/: anc_loader.c anc_mgr.c codec_mgr.c vad_mgr.c
    ../../../../src/framework/audio/path/digital/: dsp_ipc.c dsp_loader.c dsp_mgr.c
    ../../../../src/framework/audio/path/gateway/: gateway.c
    ../../../../src/framework/audio/path/loader/: bin_loader.c
    ../../../../src/framework/audio/path/plugin/: audio_plugin.c
  group probe
    ../../../../src/framework/audio/probe/: audio_probe.c
  group effect
    ../../../../src/framework/audio/effect/: audio_effect.c eq.c nrec.c sidetone.c wdrc.c beamforming.c audio_vse.c
  group volume
    ../../../../src/framework/audio/volume/: audio_volume.c
  group route
    ../../../../src/framework/audio/route/: audio_route.c audio_route_cfg.c
  group stream
    ../../../../src/framework/audio/stream/: audio_line.c audio_pipe.c audio_track.c
  group signal
    ../../../../src/framework/audio/signal/: anc.c anc_tuning.c audio_passthrough.c vad.c
