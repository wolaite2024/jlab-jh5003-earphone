# Keil uVision project btm.uvprojx, settings and files
target rtl87x3d (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: btm +hex (library)
  AfterMake: cmd.exe /c btm_after_build.bat 3d && echo %TIME%
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CONFIG_REALTEK_BTM_HID_DEVICE_SUPPORT=1 CONFIG_REALTEK_BTM_HID_HOST_SUPPORT=0 CONFIG_REALTEK_BTM_AVP_SUPPORT=1 CONFIG_REALTEK_BTM_IAP_SUPPORT=1 CONFIG_REALTEK_BTM_MAP_SUPPORT=1 CONFIG_REALTEK_BTM_ROLESWAP_SUPPORT=1 CONFIG_REALTEK_BTM_PBAP_SUPPORT=1 CONFIG_REALTEK_BTM_ATT_SUPPORT=1 CONFIG_REALTEK_BTM_AVRCP_BROWSING_SUPPORT=1 CONFIG_REALTEK_BTM_AVRCP_COVER_ART_SUPPORT=1 CONFIG_REALTEK_BTM_HFP_AG_SUPPORT=1 CONFIG_REALTEK_BTM_PAN_SUPPORT=1
  c misc: --gnu --bss_threshold=0
  c include: ..\..\..\..\inc\bluetooth\gap;..\..\..\..\inc\bluetooth\profile;..\..\..\..\inc\framework\bt;..\..\..\..\inc\framework\remote;..\..\..\..\inc\framework\sysm;..\..\..\..\src\framework\btm;..\..\..\..\inc\os;..\..\..\..\inc\platform;..\..\..\..\inc\rtl87x3d\hal\stack;..\..\..\..\inc\rtl87x3d\platform
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6314 --datacompressor off
  group btm
    ../../../../src/framework/btm/: bt_mgr.c bt_pm.c bt_gap.c bt_sdp.c bt_a2dp.c bt_avrcp.c bt_hfp.c bt_spp.c bt_pbap.c bt_iap.c bt_rdtp.c bt_rfc.c bt_avp.c bt_roleswap.c bt_roleswap_sniffing.c bt_hfp_ag.c bt_hid_parser.c bt_hid_device.c bt_hid_host.c bt_att.c bt_map.c bt_opp.c bt_pan.c
  group profile
    ../../../../src/framework/btm/: avctp.c avdtp.c iap_cp.c obex.c rfc.c bnep.c
