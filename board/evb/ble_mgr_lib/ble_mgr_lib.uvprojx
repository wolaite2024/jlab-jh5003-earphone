# Keil uVision project ble_mgr_lib.uvprojx, settings and files
target rtl87x3d (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: ble_mgr (library)
  AfterMake: cmd.exe /c ble_mgr_lib_after_build.bat 3d default && echo %TIME%
  c flags: Optim=3 uC99=1 wLevel=2
  c define: CONFIG_REALTEK_BT_GATT_CLIENT_SUPPORT=1, CONFIG_REALTEK_BT_GATT_SVC_SUPPORT=1, CONFIG_REALTEK_APP_BOND_MGR_SUPPORT=1
  c misc: --gnu --bss_threshold=0
  c include: ..\..\..\inc\os;..\..\..\inc\rtl87x3d\platform;..\..\..\inc\rtl87x3d\hal\stack;..\..\..\inc\bluetooth\gap;..\..\..\inc\ble_mgr;..\..\..\inc\rtl87x3d\bluetooth\gap;..\..\..\inc\bluetooth\profile;..\..\..\inc\ble_mgr\bond;..\..\..\src\ble_mgr\bond;..\..\..\inc\rtl87x3d\hal;..\..\..\inc\hal\platform;..\..\..\inc\hal\io;..\..\..\inc\framework\sysm;..\..\..\inc\platform;..\..\..\src\ble_mgr
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6314 --datacompressor off
  group src
    ../../../src/ble_mgr/: ble_adv_data.c ble_conn.c ble_ext_adv.c ble_mgr.c ble_scan.c bt_syscall.c bt_gatt_client.c bt_gattc_storage.c bt_gatt_svc.c gatt_service_client.c
  group bond
    ../../../src/ble_mgr/bond/: bt_bond_api.c bt_bond_common.c bt_bond_ftl.c bt_bond_le.c bt_bond_legacy.c bt_bond_priority.c
